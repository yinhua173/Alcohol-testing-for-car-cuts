# Keil uVision project 酒精检测系统.uvprojx, settings and files
target Target_1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 酒精检测系统
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\System;.\STM32F10x_StdPeriph_Driver\inc;.\User\adc;.\User\gpio;.\User\IIC;.\User\oled;.\User\YF017;.\User\delay;.\User\usart;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c
  group System
    ./System/: system_stm32f10x.c startup_stm32f10x_md.s core_cm3.c
  group User
    ./User/: main.c
    ./User/adc/: adc.c
    ./User/gpio/: key.c LED.c
    ./User/IIC/: myiic.c
    ./User/oled/: OLED.c
    ./User/YF017/: YF017.c
    ./User/delay/: delay.c
    ./User/usart/: usart.c
